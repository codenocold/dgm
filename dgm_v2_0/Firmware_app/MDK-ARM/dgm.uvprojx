# Keil uVision project dgm.uvprojx, settings and files
target dgm (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32C103CB GigaDevice
  pack: GigaDevice.GD32C10x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dgm_fw +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32C10X,ARM_MATH_CM4
  c misc: --c99
  c include: ..\Source;..\CMSIS;..\CMSIS\GD\GD32C10x\Include;..\GD32C10x_standard_peripheral\Include;..\GD32C10x_usbfs_library\driver\Include;..\GD32C10x_usbfs_library\device\core\Include;..\GD32C10x_usbfs_library\device\class\cdc\Include;..\GD32C10x_usbfs_library\ustd\common;..\GD32C10x_usbfs_library\ustd\class\cdc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../Source/: main.c gd32c10x_it.c led.c uart.c can.c systick.c pwm_curr_fdbk.c encoder.c controller.c foc.c fsm.c trapTraj.c calibration.c anticogging.c usr_config.c util.c heap.c
  group GD32C10x_StdPeriph_Driver
    ../GD32C10x_standard_peripheral/Source/: gd32c10x_dma.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_gpio.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_ctc.c gd32c10x_can.c gd32c10x_dbg.c gd32c10x_fwdgt.c gd32c10x_spi.c gd32c10x_adc.c
  group CMSIS
    ../CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group Startup
    ../CMSIS/GD/GD32C10x/Source/ARM/: startup_gd32c10x.s
  group Doc
    ../: readme.txt
