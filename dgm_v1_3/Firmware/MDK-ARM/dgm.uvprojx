# Keil uVision project dgm.uvprojx, settings and files
target dgm (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32E103C8 GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x05000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: dgm_fw +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X,ARM_MATH_CM4
  c misc: --c99
  c include: ..\inc;..\CMSIS;..\CMSIS\GD\GD32E10x\Include;..\GD32E10x_standard_peripheral\Include;..\GD32E10x_usbfs_library\driver\Include;..\GD32E10x_usbfs_library\device\core\Include;..\GD32E10x_usbfs_library\device\class\cdc\Include;..\GD32E10x_usbfs_library\ustd\common;..\GD32E10x_usbfs_library\ustd\class\cdc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../src/: main.c gd32e10x_it.c systick.c led.c pwm_curr_fdbk.c drv8323.c uart.c foc.c calibration.c controller.c encoder.c fsm.c util.c usr_config.c trapTraj.c can.c
  group GD32E10x_StdPeriph_Driver
    ../GD32E10x_standard_peripheral/Source/: gd32e10x_dma.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_gpio.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_ctc.c gd32e10x_can.c gd32e10x_dbg.c gd32e10x_fwdgt.c gd32e10x_spi.c gd32e10x_adc.c
  group CMSIS
    ../CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
  group Startup
    ../CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Doc
    ../: readme.txt
